## board/uct/rhino/Kconfig
```kconfig
if TARGET_RHINO

config SYS_BOARD
	default "rhino"

config SYS_VENDOR
	default "uct"

config SYS_CONFIG_NAME
	default "rhino"

endif
```
